# Keil uVision project stm32-project.uvprojx, settings and files
target stm32-project (6210000::V6.21::.\ARMCLANG_621)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: stm32-project +hex
  c flags: Optim=5 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xE,ARM_MATH_CM3
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../UserApp/Lib/FreeRTOS/include;../UserApp/Lib/FreeRTOS/portable/GCC/ARM_CM3;../UserApp/Lib/CMSIS/DSP/include;../UserApp/Device;../UserApp/Main
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group FreeRTOS/Source
    ../UserApp/Lib/FreeRTOS/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c croutine.c
  group FreeRTOS/Portable
    ../UserApp/Lib/FreeRTOS/portable/GCC/ARM_CM3/: port.c
    ../UserApp/Lib/FreeRTOS/portable/MemMang/: heap_4.c
  group UserApp/Lib
    ../UserApp/Lib/CMSIS/DSP/lib/ARM/: arm_cortexM3l_math.lib
  group UserApp/Device
    ../UserApp/Device/: device_uart_it.c device_uart_dma.c
  group UserApp
    ../UserApp/Main/: user_main.c user_main_it.c user_main_dma.c
target FreeRTOS_IT (6210000::V6.21::.\ARMCLANG_621)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: FreeRTOS_IT +hex
  c flags: Optim=5 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xE,ARM_MATH_CM3
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
target FreeRTOS_DMA (6210000::V6.21::.\ARMCLANG_621)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: FreeRTOS_DMA +hex
  c flags: Optim=5 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xE,ARM_MATH_CM3
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
software components: CMSIS:CORE 5.6.0
